
# See https://patchwork.openembedded.org/patch/144396/
EXTRA_OEMAKE_append = "\
	'LDCONFIG=:' \
	"